# Keil uVision project STM32CubeDefault.uvprojx, settings and files
target STM32CubeDefault (6190000::V6.19::ARMCLANG)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32CubeDefault +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\Source\BSW\CAN\CAN_DIAGCOM\inc;../Source/BSW/CAN/CAN_IF/inc;../Source/BSW/CAN/CAN_NM/inc;../Source/Public;../Source/LIB/FIFO/inc;../Source/LIB/FSM/inc;../Source/LIB/SERVICE/inc;../Source/LIB/TIMER/inc;../Source/LIB/TYPE/inc;..\Source\BSW\CAN\CAN_IL\inc;..\Source\BSW\CAN\CAN_MESSAGE\inc;..\Source\BSW\CAN\CAN_TASK\inc;..\Source\BSW\CAN\CAN_TP\inc;..\Source\BSW\UART\inc;..\Source\BSW\UDS\cfg\inc;..\Source\BSW\UDS\cfg
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c crc.c rtc.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_can.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group BSW/CAN/CAN_DIAGCOM
    ../Source/BSW/CAN/CAN_DIAGCOM/src/: LibDiagCom.c LibUdsAssist.c
  group BSW/CAN/CAN_IF
    ../Source/BSW/CAN/CAN_IF/src/: CanIF.c LibCanDrvMsg.c
  group BSW/CAN/CAN_IL
    ../Source/BSW/CAN/CAN_IL/src/: LibCanIL.c
  group BSW/CAN/CAN_MESSAGE
    ../Source/BSW/CAN/CAN_MESSAGE/src/: LibCanCfg_FiltTbl.c LibCanIlCbk.c LibCanILCfg.c LibCanMsg.c
  group BSW/CAN/CAN_NM
    ../Source/BSW/CAN/CAN_NM/src/: CanNm.c CanNmHistory.c CanNmMgr.c CanNmMsgs.c
  group BSW/CAN/CAN_TASK
    ../Source/BSW/CAN/CAN_TASK/src/: CanTask.c
  group BSW/CAN/CAN_TP
    ../Source/BSW/CAN/CAN_TP/src/: LibCanTp.c LibCanTpCfg.c LibCanTpFsm.c LibCanTpInternal.c
  group BSW/UART
    ../Source/BSW/UART/src/: UartIF.c
  group LIB/FIFO
    ../Source/LIB/FIFO/src/: LibFifoQueue.c
  group LIB/FSM
    ../Source/LIB/FSM/src/: LibFsm.c
  group LIB/SERVICE
    ../Source/LIB/SERVICE/src/: LibService.c LibServiceHost.c
  group LIB/TIMER
    ../Source/LIB/TIMER/src/: LibTimer.c
  group LIB/TYPE
    ../Source/LIB/TYPE/src/: LibTypes.c
software components: CMSIS:CORE 5.6.0
